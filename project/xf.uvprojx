# Keil uVision project xf.uvprojx, settings and files
target xf (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: xf
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: __MSPM0G3507__
  c include: ..\lib\ti\CMSIS;..\FreeRTOS;..\FreeRTOS\include;..\user;..\FreeRTOS\portable\ARM_CM0;..\Task;..\Hardware\ws2812;..\Hardware\UART;..\Hardware\Timer;..\Hardware\servo;..\Hardware\PID;..\Hardware\oled;..\Hardware\Motor;..\Hardware\LED_Key;..\Hardware\Enconder;..\Hardware\IMU;..\Hardware\delay;..\Hardware\control;..\Hardware\MaixCam;..\Hardware\YunQue;..\Hardware\Emm_V5;..\BSP\UART
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\Objects\xf.sct
  group lib
    ../lib/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../lib/ti/driverlib/m0p/: dl_interrupt.c
    ../lib/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
    ../lib/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group user
    ../user/: main.c ti_msp_dl_config.c ti_msp_dl_config.h main.h main.syscfg
  group Startup
    ../lib/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
  group FreeRTOS_PORT
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/ARM_CM0/: port.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group Task
    ../Task/: StartupTask.c
  group Hardware
    ../Hardware/ws2812/: ws2812b.c ws2812b.h
    ../Hardware/UART/: UART.c UART.h
    ../Hardware/servo/: servo.c servo.h
    ../Hardware/oled/: oled.c oled.h OLED_Font.h
    ../Hardware/Motor/: Motor.c Motor.h
    ../Hardware/LED_Key/: LED_Key.c LED_Key.h
    ../Hardware/Enconder/: Enconder.c Enconder.h
    ../Hardware/delay/: delay.c delay.h
    ../Hardware/control/: control.c
    ../Hardware/MaixCam/: MaixCam.c
    ../Hardware/YunQue/: YunQue.c
    ../Hardware/Emm_V5/: Emm_V5.c
  group BSP
    ../BSP/UART/: bsp_uart.c
